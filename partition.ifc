Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [DesignTransferView]
File name: partition.ifc
Time: 2026-09-17T00:00:00
Author: INVISIBLE DOORS
Organization: INVISIBLE DOORS
Written by: Partitions Designer Export
Made in: Partitions Designer Export

# IfcBuildingStorey, Finished floor
In: Building
Elevation: 0 m

# IfcBuildingElementProxy: InteriorPartition, Синхро: две створки, 1 трек
In: Finished floor
Description: Interior visualisation and coordination; not fabrication geometry; PredefinedType: USERDEFINED
INVISIBLE_DOORS_Configuration - Manufacturer: INVISIBLE DOORS; Category: Interior partition; Pose: closed; FamilyId: loft; SystemId: SYS_ALONG_WALL; SchemeId: SCH_AW_SYN2; MountingId: MNT_WALL_CORNICE; LeafDesignId: LD_LOFT_GRID_H3; FinishId: FIN_PROFILE_BLACK; InfillId: GLASS_M1_PROZRACHNOE; OpeningWidthMm: 1600; OpeningHeightMm: 2700; GeometryRevision: geometry-v2-optional-fixed-sides-2026-09-23
